# Repository BenK3nobi/Bmaps

## KiCad design TESLA-V-1.0/AMR_3D_08_11_2016_copy.kicad_pcb

Parts:
C1, C2: C; SMD-2512_Pol
P1, P2: CONN_01X01; Pin_Header_Straight_1x01
P3: CONN_02X15; Multicomp_MC9A22-3434_2x17x2.54mm_Angled
P4: CONN_02X05; Multicomp_MC9A22-1034_2x05x2.54mm_Angled
P5: CONN_02X02; Pin_Header_Straight_2x02
R1: R; Resistor_Horizontal_RM10mm
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15: AFF755b; DIP-8_W7.62mm

Connections:
+6V: P4.4, U1.3 (Itest+)
+9V: P1.1, P4.6, R1.2
+12V: P4.2, U1.1 (If+)
LP: U2.6 (Vcc+)
LP2-: P4.5
LP+: C1.1, C2.1, P2.1, R1.1, U1.6 (Vcc+), U3.6 (Vcc+), U4.6 (Vcc+), U5.6 (Vcc+), U6.6 (Vcc+), U7.6 (Vcc+), U8.6 (Vcc+), U9.6 (Vcc+), U10.6 (Vcc+), U11.6 (Vcc+), U12.6 (Vcc+), U13.6 (Vcc+), U14.6 (Vcc+), U15.6 (Vcc+)
LP-: C1.2, C2.2, P4.1, P4.3, U1.4 (Vcc-), U2.4 (Vcc-), U3.4 (Vcc-), U4.4 (Vcc-), U5.4 (Vcc-), U6.4 (Vcc-), U7.4 (Vcc-), U8.4 (Vcc-), U9.4 (Vcc-), U10.4 (Vcc-), U11.4 (Vcc-), U12.4 (Vcc-), U13.4 (Vcc-), U14.4 (Vcc-), U14.7 (Itest-), U14.8 (If-), U15.4 (Vcc-)
unnamed: U1.7 (Itest-), U3.3 (Itest+)
unnamed: U1.8 (If-), U3.1 (If+)
unnamed: U2.1 (If+), U3.8 (If-)
unnamed: U2.3 (Itest+), U3.7 (Itest-)
unnamed: U2.7 (Itest-), U4.3 (Itest+)
unnamed: U2.8 (If-), U4.1 (If+)
unnamed: U4.7 (Itest-), U6.3 (Itest+)
unnamed: U4.8 (If-), U6.1 (If+)
unnamed: U5.1 (If+), U6.8 (If-)
unnamed: U5.3 (Itest+), U6.7 (Itest-)
unnamed: U5.7 (Itest-), U7.3 (Itest+)
unnamed: U5.8 (If-), U7.1 (If+)
unnamed: U7.7 (Itest-), U9.3 (Itest+)
unnamed: U7.8 (If-), U9.1 (If+)
unnamed: U8.1 (If+), U9.8 (If-)
unnamed: U8.3 (Itest+), U9.7 (Itest-)
unnamed: U8.8 (If-), U10.1 (If+)
unnamed: U8.7 (Itest-), U10.3 (Itest+)
unnamed: U10.7 (Itest-), U12.3 (Itest+)
unnamed: U10.8 (If-), U12.1 (If+)
unnamed: U11.1 (If+), U12.8 (If-)
unnamed: U11.3 (Itest+), U12.7 (Itest-)
unnamed: U11.7 (Itest-), U13.3 (Itest+)
unnamed: U11.8 (If-), U13.1 (If+)
unnamed: U13.7 (Itest-), U15.3 (Itest+)
unnamed: U13.8 (If-), U15.1 (If+)
unnamed: U14.1 (If+), U15.8 (If-)
unnamed: U14.3 (Itest+), U15.7 (Itest-)
U1+: P3.2, U1.5 (Vout+)
U1-: P3.1, U1.2 (Vout-)
U2+: P3.4, U3.5 (Vout+)
U2-: P3.3, U3.2 (Vout-)
U3+: P3.6, U2.5 (Vout+)
U3-: P3.5, U2.2 (Vout-)
U4+: P3.8, U4.5 (Vout+)
U4-: P3.7, U4.2 (Vout-)
U5+: P3.10, U6.5 (Vout+)
U5-: P3.9, U6.2 (Vout-)
U6+: P3.12, U5.5 (Vout+)
U6-: P3.11, U5.2 (Vout-)
U7+: P3.14, U7.5 (Vout+)
U7-: P3.13, U7.2 (Vout-)
U8+: P3.16, U9.5 (Vout+)
U8-: P3.15, U9.2 (Vout-)
U9+: P3.18, U8.5 (Vout+)
U9-: P3.17, U8.2 (Vout-)
U10+: P3.20, U10.5 (Vout+)
U10-: P3.19, U10.2 (Vout-)
U11+: P3.22, U12.5 (Vout+)
U11-: P3.21, U12.2 (Vout-)
U12+: P3.24, U11.5 (Vout+)
U12-: P3.23, U11.2 (Vout-)
U13+: P3.26, U13.5 (Vout+)
U13-: P3.25, U13.2 (Vout-)
U14+: P3.28, U15.5 (Vout+)
U14-: P3.27, U15.2 (Vout-)
U15+: P3.30, U14.5 (Vout+)
U15-: P3.29, U14.2 (Vout-)

Board: 2 copper layers, 267.9 x 125.0 mm, 22 parts (0 on the bottom side), 63 nets.

## Commit log

2018-02-22 All files for the Boards of Version 1 added and committed. Committer: Schmitz <ltu@basisit.de> On branch master Initial commit Changes to be committed: new file: AMR_3D_05_01_2017.zip new file: AMR_3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
2018-02-22 Versio 0.9, Phi Sensors have a smaller pin distance.
    Committer: Schmitz <ltu@basisit.de>
    On branch master
    Initial commit
    Changes to be committed:
    new file: AMR_3D_08_11_2016-B.Adhes.gba
    new file: AMR_3D_08_11_2016-B.Cu.gbl
2018-03-14 Initial Commit for the new version of smd boards. Committer: Schmitz <ltu@basisit.de> Changes to be committed: new file: AMR_3D_17_06_2017-cache.lib new file: AMR_3D_17_06_2017.kicad_pcb new file: AM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
2018-03-14 Initial commit for VSR Singlecell BMap Board. Committer: Schmitz <ltu@basisit.de> Changes to be committed: new file: AMR_3D_VSR_SingleCell-cache.lib new file: AMR_3D_VSR_SingleCell.bak new file: AMR_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
2018-03-14 Korrekte Ellipse für das VSR Shape eingefügt. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb new file: drawing.dxf new file: drawing2.dxf
2018-03-19 Introduced the shape for the boards in svg. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: drawing.dxf new file: drawing.svg
2018-03-19 New PCB Layout included, Routing of the signal channesl done. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.ki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
2018-03-19 Testspulen verdrahtet. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak
2018-03-20 Filling of the Cu Plane fixed. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak
2018-03-20 HZB Logo added to library and to the PCB. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak modified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
2018-03-21 Adjusted length of the steps of the pcb. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak
2018-03-21 Drillholes + additional load included. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak
2018-03-21 Leiterbahn für die zusätlich load korrigiert. Committer: Schmitz <ltu@basisit.de> Changes to be committed: modified: AMR_3D_VSR_SingleCell.kicad_pcb modified: AMR_3D_VSR_SingleCell.kicad_pcb-bak
2019-07-29 Additional folder included.
2019-07-29 Aditional folder inserted.
2019-07-29 Initialised. Initialer Commit zum Commit vorgemerkte Änderungen: neue Datei: info.txt
2019-07-29 Initialiasation of the correct files.
2019-09-03 addaing articles
2019-09-09 Corrsponding RSI Paper included.
